# Keil uVision project Project.uvprojx, settings and files
target STM3210E_EVAL (ARM-ADS)
  device: STM32F103ZG STMicroelectronics
  cpu: IRAM(0x20000000-0x20017FFF) IROM(0x8000000-0x80FFFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: STM3210E_EVAL
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xG,USE_STM3210E_EVAL
  c misc: --C99
  c include: ../Inc;../../../../../../Drivers/CMSIS/Device/ST/STM32F1xx/Include;../../../../../../Drivers/STM32F1xx_HAL_Driver/Inc;../../../../../../Drivers/BSP/STM3210E_EVAL;../../../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM3;../../../../../../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS;../../../../../../Middlewares/Third_Party/FreeRTOS/Source/include
  asm include: ROJ_DIR$\..\Inc
  library: MicroLIB
  link misc: --diag_suppress=L6329
  group Application/User
    ../Src/: main.c stm32f1xx_it.c
  group Middlewares/FreeRTOS/portable
    ../../../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../../../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM3/: port.c
  group Doc
    ../: readme.txt
  group Middlewares/FreeRTOS
    ../../../../../../Middlewares/Third_Party/FreeRTOS/Source/: timers.c list.c tasks.c queue.c
  group Middlewares/FreeRTOS/CMSIS_RTOS
    ../../../../../../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
  group Drivers/STM32F1xx_HAL_Driver
    ../../../../../../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_cortex.c stm32f1xx_hal.c stm32f1xx_hal_gpio.c
  group Drivers/CMSIS
    ../Src/: system_stm32f1xx.c
  group Drivers/BSP/STM3210E_EVAL
    ../../../../../../Drivers/BSP/STM3210E_EVAL/: stm3210e_eval.c
  group Application/MDK-ARM
    ./: startup_stm32f103xg.s
software components: CMSIS:CORE 4.1.0
