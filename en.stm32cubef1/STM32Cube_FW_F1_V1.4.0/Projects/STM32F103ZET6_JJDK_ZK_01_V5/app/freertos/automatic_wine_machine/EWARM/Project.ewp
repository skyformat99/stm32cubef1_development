# IAR project Project.ewp, settings and files
configuration RELEASE (ARM)
  General.OGChipSelectEditMenu: STM32F103C8 ST STM32F103C8
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32F103xB; USE_STM3210C_wkxboot; DEBUG=1
  ICCARM.CCIncludePath2: ..\Inc; ..\..\..\..\..\..\Drivers\CMSIS\Device\ST\STM32F1xx\Include; ..\..\..\..\..\..\Drivers\STM32F1xx_HAL_Driver\Inc; ..\..\..\..\..\..\Drivers\BSP\STM3210C_EVAL; ..\..\..\..\..\..\Middlewares\Third_Party\FreeRTOS\Source\portable\IAR\ARM_CM3; ..\..\..\..\..\..\Middlewares\Third_Party\FreeRTOS\Source\CMSIS_RTOS; ..\..\..\..\..\..\Middlewares\Third_Party\FreeRTOS\Source\include; C:\Program Files (x86)\IAR Systems\Embedded Workbench 8.0\arm\src\flashloader\NXP\FlashQN9080\chip_qn908x\cmsis
  ICCARM.CCOptLevel: 2
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\Inc
  OBJCOPY.OOCOutputFile: Project.srec
  ILINK.IlinkOutputFile: Project.out
  ILINK.IlinkIcfFile: stm32f107xc_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration DEBUG (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: STM32F103ZE ST STM32F103ZE
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32F103xE; USE_STM32F103ZET6_JJDK_ZK_01_V5; DEBUG=1
  ICCARM.CCOptLevel: 0
  group Application/EWARM
    ./: startup_stm32f103xg.s
  group Application/User
    ../Src/: debug.c main.c stm32f1xx_hal_msp.c stm32f1xx_it.c
  group Doc
    ../: readme.txt
  group Drivers/BSP/STM32F103ZET6_JJDK_ZK_01_V5
    ../../../../../../Drivers/BSP/STM32F103ZET6_JJDK_ZK_01_V5/: stm32f103zet6_jjdk_zk_01_v5.c
  group Drivers/CMSIS
    ../Src/: system_stm32f1xx.c
  group Drivers/STM32F1xx_HAL_Driver
    ../../../../../../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal.c stm32f1xx_hal_cortex.c stm32f1xx_hal_dma.c stm32f1xx_hal_gpio.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_uart.c
  group Middlewares/FreeRTOS
    ../../../../../../Middlewares/Third_Party/FreeRTOS/Source/: list.c queue.c tasks.c timers.c
  group Middlewares/FreeRTOS/CMSIS_RTOS
    ../../../../../../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
  group Middlewares/FreeRTOS/portable
    ../../../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../../../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/IAR/ARM_CM3/: port.c portasm.s
